## config/boards/shields/niceV2/Kconfig.shield
```kconfig
config SHIELD_NICEV2
    bool "niceV2"
    depends on BOARD_NICE_NANO_V2  // 改为nice!nano V2.0的开发板依赖
```
